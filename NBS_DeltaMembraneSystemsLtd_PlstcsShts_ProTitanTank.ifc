Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2024-10-15T11:42:08
Written by: ODA IFC SDK 22.8
Made in: 22.1.70.9 - Exporter 22.4.0.0 - Alternate UI 22.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status
COBie - Category: Project Information

# IfcSite, Default
RefLatitude: 51, 30, 0, 549316; RefLongitude: 0, -7, -34, -450321; RefElevation: 0 mm
COBie - Category: Project Information

# IfcBuilding
COBie - Category: Project Information

# IfcBuildingStorey: Level:Circle Head - Project Datum, Level 0
LongName: Level 0; Elevation: 0 mm
COBie - Category: Levels; Name: Level 0

# IfcCovering: Basic Wall:NBS_DeltaMembraneSystemsLtd_PlasticsSheets_ProTitanTank, Basic Wall:NBS_DeltaMembraneSystemsLtd_PlasticsSheets_ProTitanTank:222187
In: Level 0
Type - PredefinedType: MEMBRANE; Material: NBS_DeltaMembraneSystemsLtd_PlasticsSheets_ProTitanTank 1.2 mm
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: MEMBRANE
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_25_57_65_60: Plastics sheets; Color: n/a; Finish: n/a; Material: Polyethylene; Shape: n/a; Size: n/a; WarrantyDescription: 60 year; CodePerformance: n/a; Constituents: n/a; Description: Post applied polyethylene waterproofing membrane and ground gas protection membrane.; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Grade: n/a; Manufacturer: info@deltamembranes.com; ModelNumber: n/a; ModelReference: Pro Titan Tank; Name: PlasticsSheets_ProTitanTank_DeltaMembraneSystemsLtd; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_DeltaMembraneSystemsLtd_PlasticsSheets_ProTitanTank; ManufacturerName: Delta Membrane Systems Ltd; ManufacturerURL: https://www.deltamembranes.com; ProductInformation: https://source.thenbs.com/product/-/0956f470-d6ea-03f9-e391-89e3b161fe3d/96278b60-5f61-4471-af34-5201e5aa86b0; Uniclass2015Code: Pr_25_57_65_60; Uniclass2015Title: Plastics sheets; Uniclass2015Version: Products v1.35; Version: 8
Type - NBS_Data - PerformanceCharacteristicsTensileStrengthMinimum: >550 N/50 mm and >400 N/50 mm; PerformanceCharacteristicsTearResistance: >300 N; PerformanceCharacteristicsFirePerformance: To BS EN ISO 11925-2, class E; PhysicalPropertiesWeightMinimum: 1000 g/m²; PhysicalPropertiesDimensionsThicknessMinimum: 1.2 mm; PhysicalPropertiesDimensionsRollLengthMinimum: 20 m; Purpose: Gas protection system; RecycledContent: 0; Standard: To BS EN 14414 and BS EN 14415; Third-partyCertification: CE marked to BS EN 13967; ContainsRedListMaterials: No; Material: Polyethylene; Recyclability: No; Dimensions: 300 mm,1000 mm; WaterVapourTransmission: 0.14 g/m²/day
Classification: Pr_25_57_65_60 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcCovering: Floor:NBS_DeltaMembraneSystemsLtd_PlasticsSheets_ProTitanTank, Floor:NBS_DeltaMembraneSystemsLtd_PlasticsSheets_ProTitanTank:221901
In: Level 0
Type - PredefinedType: MEMBRANE; Material: NBS_DeltaMembraneSystemsLtd_PlasticsSheets_ProTitanTank 1.2 mm
Type - IFC - IfcExportAs: IfcCoveringType; IfcExportType: MEMBRANE
Type - COBie - NominalHeight: 0 mm; NominalLength: 0 mm; NominalWidth: 0 mm; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_25_57_65_60: Plastics sheets; Color: n/a; Finish: n/a; Material: Polyethylene; Shape: n/a; Size: n/a; WarrantyDescription: 60 year; CodePerformance: n/a; Constituents: n/a; Description: Post applied polyethylene waterproofing membrane and ground gas protection membrane.; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Grade: n/a; Manufacturer: info@deltamembranes.com; ModelNumber: n/a; ModelReference: Pro Titan Tank; Name: PlasticsSheets_ProTitanTank_DeltaMembraneSystemsLtd; ReplacementCost: n/a; SustainabilityPerformance: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - BOS_General - Author: NBS; BIMObjectName: NBS_DeltaMembraneSystemsLtd_PlasticsSheets_ProTitanTank; ManufacturerName: Delta Membrane Systems Ltd; ManufacturerURL: https://www.deltamembranes.com; ProductInformation: https://source.thenbs.com/product/-/0956f470-d6ea-03f9-e391-89e3b161fe3d/1f039285-1c11-4864-811a-13f10dcf2b87; Uniclass2015Code: Pr_25_57_65_60; Uniclass2015Title: Plastics sheets; Uniclass2015Version: Products v1.35; Version: 7
Type - NBS_Data - PerformanceCharacteristicsTensileStrengthMinimum: >550 N/50 mm and >400 N/50 mm; PerformanceCharacteristicsTearResistance: >300 N; PerformanceCharacteristicsFirePerformance: To BS EN ISO 11925-2, class E; PhysicalPropertiesWeightMinimum: 1000 g/m²; PhysicalPropertiesDimensionsThicknessMinimum: 1.2 mm; PhysicalPropertiesDimensionsRollLengthMinimum: 20 m; Purpose: Gas protection system; RecycledContent: 0; Standard: To BS EN 14414 and BS EN 14415; Third-partyCertification: CE marked to BS EN 13967; ContainsRedListMaterials: No; Material: Polyethylene; Recyclability: No; Dimensions: 300 mm,1000 mm; WaterVapourTransmission: 0.14 g/m²/day
Classification: Pr_25_57_65_60 (Uniclass2015)
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
